# Keil uVision project Nrf51_GPIO.uvprojx, settings and files
target Nrf51_GPIO (5050169::V5.05 update 2 (build 169)::..\..\Keil_v5\ARM\ARMCC)
  device: nRF51822_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.5.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Nrf51_GPIO
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: NRF51
  c include: .\UsrCode;..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf;..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\hal;..\nRF5_SDK_12.3.0_d7731ad\components\libraries\util;..\nRF5_SDK_12.3.0_d7731ad\components\softdevice\s132\headers;..\nRF5_SDK_12.3.0_d7731ad\components\device;..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\delay
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group UsrCode
    ./UsrCode/: UsrCode.c UsrLed.c
  group Nrf_Lib
    ../nRF5_SDK_12.3.0_d7731ad/components/drivers_nrf/common/: nrf_drv_common.c
    ../nRF5_SDK_12.3.0_d7731ad/components/drivers_nrf/hal/: nrf_adc.c nrf_ecb.c nrf_nvmc.c nrf_saadc.c
software components: CMSIS:CORE 5.3.0, Device:Startup 8.5.0

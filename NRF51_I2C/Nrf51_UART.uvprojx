# Keil uVision project Nrf51_UART.uvprojx, settings and files
target Nrf51822 (ARM-ADS)
  device: nRF51822_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.59.0
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00008000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Nrf51_UART +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: NRF51 NRF51822 BSP_DEFINES_ONLY BOARD_PCA10028 RETARGET_ENABLED
  c include: .\UsrCode;..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf;..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\hal;..\nRF5_SDK_12.3.0_d7731ad\components\libraries\util;..\nRF5_SDK_12.3.0_d7731ad\components\softdevice\s132\headers;..\nRF5_SDK_12.3.0_d7731ad\components\device;..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\delay;..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\uart;..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\common;..\nRF5_SDK_12.3.0_d7731ad\components\libraries\log;..\nRF5_SDK_12.3.0_d7731ad\components\libraries\log\src;..\nRF5_SDK_12.3.0_d7731ad\components\libraries\uart;..\nRF5_SDK_12.3.0_d7731ad\components\libraries\util;..\nRF5_SDK_12.3.0_d7731ad\components\libraries\fifo;..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\timer;..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\twi_master;..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\twi_master\deprecated;..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\twi_master\deprecated\config;.\UsrCode\MultiButton-master;.\UsrCode\osal\osal
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Nrf_Lib
    ../nRF5_SDK_12.3.0_d7731ad/components/drivers_nrf/common/: nrf_drv_common.c
    ../nRF5_SDK_12.3.0_d7731ad/components/drivers_nrf/uart/: nrf_drv_uart.c
    ../nRF5_SDK_12.3.0_d7731ad/components/libraries/uart/: app_uart.c app_uart_fifo.c retarget.c
    ../nRF5_SDK_12.3.0_d7731ad/components/libraries/util/: app_error.c app_error_weak.c nrf_assert.c
    ../nRF5_SDK_12.3.0_d7731ad/components/libraries/fifo/: app_fifo.c
    ../nRF5_SDK_12.3.0_d7731ad/components/drivers_nrf/timer/: nrf_drv_timer.c
    ../nRF5_SDK_12.3.0_d7731ad/components/drivers_nrf/twi_master/: nrf_drv_twi.c
    ../nRF5_SDK_12.3.0_d7731ad/components/drivers_nrf/twi_master/deprecated/: twi_hw_master.c
  group Osal_Lib
    ./UsrCode/osal/osal/: osal.c osal_event.c osal_memory.c osal_msg.c osal_timer.c
  group Oth_Lib
    ./UsrCode/MultiButton-master/: multi_button.c
  group UsrCode
    ./UsrCode/: Usr_Code.c Usr_Led.c Usr_Timer.c Usr_Uart.c Usr_I2C.c Usr_Osal.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.11.1
